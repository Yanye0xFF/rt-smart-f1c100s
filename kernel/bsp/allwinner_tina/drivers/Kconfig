## kernel/bsp/allwinner_tina/drivers/Kconfig
```kconfig
config TINA_USING_UART0
    bool "Using UART0"
    select RT_USING_SERIAL
    default y
```
